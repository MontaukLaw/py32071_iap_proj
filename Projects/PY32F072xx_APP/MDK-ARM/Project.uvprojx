# Keil uVision project Project.uvprojx, settings and files
target PY32F072xB_Project (6220000::V6.22::ARMCLANG)
  device: PY32F072xB Puya
  pack: Puya.PY32F0xx_DFP.1.2.2
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,PY32F072xB
  c include: ..\Inc;..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\Device\PY32F07X\Include;..\..\..\Drivers\PY32F07X_HAL_Driver\Inc;..\..\..\Drivers\BSP\PY32F072xx_Start_Kit
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Common
    ./: startup_py32f072xx.s
    ../Src/: system_py32f07x.c
  group Application/User
    ../Src/: main.c py32f07x_hal_msp.c py32f07x_it.c
  group Drivers/BSP/PY32F072xx_Start_Kit
    ../../../Drivers/BSP/PY32F072xx_Start_Kit/: py32f072xx_Start_Kit.c
  group Drivers/PY32F07x_HAL_Driver
    ../../../Drivers/PY32F07x_HAL_Driver/Src/: py32f07x_hal.c py32f07x_hal_cortex.c py32f07x_hal_dma.c py32f07x_hal_gpio.c py32f07x_hal_rcc.c py32f07x_hal_rcc_ex.c py32f07x_hal_pwr.c py32f07x_hal_usart.c py32f07x_hal_uart.c
  group Doc
    ../: readme.txt
